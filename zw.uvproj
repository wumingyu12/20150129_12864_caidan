# Keil uVision project zw.uvproj, settings and files
target zw (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: zw +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./src/: main.c LCD12864.c Finger_Modle.c
